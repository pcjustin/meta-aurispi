RPI_EXTRA_CONFIG:append = " \
        dtoverlay=vc4-kms-v3d,noaudio \
"
